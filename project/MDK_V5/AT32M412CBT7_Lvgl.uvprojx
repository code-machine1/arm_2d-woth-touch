# Keil uVision project AT32M412CBT7_Lvgl.uvprojx, settings and files
target AT32M412CBT7_Lvgl (6220000::V6.22::ARMCLANG)
  device: AT32M412CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32M412CBT7_Lvgl +hex
  AfterMake: C:\Users\18067\Desktop\AT32M412CBT7_ARM2D\project\MDK_V5\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32M412CBT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\inc;..\system;..\app;..\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32m412_416_int.c at32m412_416_wk_config.c main.c wk_system.c wk_spi.c wk_usart.c wk_dma.c wk_gpio.c wk_wdt.c
  group firmware
    ../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_gpio.c at32m412_416_usart.c at32m412_416_pwc.c at32m412_416_spi.c at32m412_416_dma.c at32m412_416_debug.c at32m412_416_flash.c at32m412_416_wdt.c at32m412_416_misc.c
  group cmsis
    ./: startup_at32m412_416.s
    ../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group system
    ../system/: TMT.c
  group device
    ../device/: at32_Usart.c util_queue.c lcd.c lcd_init.c bsp_lcd_spi.c touch.c
software components: Acceleration:Arm-2D Demos:Monochrome 1.6.1, Acceleration:Arm-2D Extras:Controls 2.6.9, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.13.1, Acceleration:Arm-2D Extras:Loaders 2.1.1, Acceleration:Arm-2D Helper:Display Adapter 3.4.0, Acceleration:Arm-2D Helper:PFB 2.7.3, Acceleration:Arm-2D Helper:Scene 1.3.3, Acceleration:Arm-2D:Alpha-Blending 1.2.4-dev, Acceleration:Arm-2D:Core 1.2.4-dev, Acceleration:Arm-2D:Filter 1.2.4-dev, Acceleration:Arm-2D:Transform 1.2.4-dev, CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0, Utilities:perf_counter:Core 2.4.0, Compiler:I/O:STDOUT 1.2.0
